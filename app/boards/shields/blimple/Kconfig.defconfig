## app/boards/shields/blimple/Kconfig.shield
```kconfig
# Copyright (c) 2021 Fabian Maisberger
# SPDX-License-Identifier: MIT

config SHIELD_BLIMPLE
	def_bool $(shields_list_contains,blimple)
```
